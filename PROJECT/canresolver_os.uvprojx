# Keil uVision project canresolver_os.uvprojx, settings and files
target canresolver_os (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: canresolver_os +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\CORE;..\CMSIS;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\CAN;..\HARDWARE\LED;..\USER;..\HARDWARE\UART;..\SYSTEM\crc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: stm32f10x_it.c system_stm32f10x.c
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: usart2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/crc/: crc8.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_dma.c
  group USER
    ../USER/: main.c can_speed.c speed_send_task.c schedule_task.c can_task.c
